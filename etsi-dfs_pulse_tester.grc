options:
  parameters:
    comment: |-
      DFS tester to verify AP DFS operation
      using HackRF One SDR. 

      Contributions:
       - Adrian Granados (original author)
       - Nigel Bowden
       - Kristian Winckler

      v0.01 - 31st Dec 2017 - Initial dev build
      v0.02 - 1st Jan 2018 - Added RF gate for on/off function
      v0.03 - 4th Jan 2018 - Rearranged UI widgets and set labels
      v0.04 - 20th Oct 2022 - Changed to ETSI standard (ETSI EN 301 893)
    generate_options: qt_gui
    id: DFS_Pulse_Tester
    output_language: python
  states: {}

blocks:
- name: Channel_Center_Freq
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      List chooser in GUI to select the channel
      our HackRF will transmit on - NB
    gui_hint: 0,0,1,1
    label: Channel
    labels: '["52 | 5260", "56 | 5280", "60 | 5300", "64 | 5320", "100 | 5500", "104 | 5520", "108 | 5540", "112 | 5560", "116 | 5580", "120 | 5600", "124 | 5620", "128 | 5640", "132 | 5660", "136 | 5680", "140 | 5700"]'
    num_opts: '0'
    options: '[5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000]'
    type: int
    value: '5260000000'
  states: {}
- name: DFS_Pattern
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      List chooser to select the DFS
      pattern we would like to test - NB
    gui_hint: 0,1
    label: Radar Signature
    labels: |
      ["ETSI Type 1", "ETSI Type 2", "ETSI Type 3", "ETSI Type 4", "ETSI Type 5", "ETSI Type 6"]
    num_opts: '0'
    options: |
      [[1]*1 + [0]*750, [1]*2 + [0]*300, [1]*10 + [0]*2300, [1]*20 + [0]*3000, [1]*1 + [0]*300, [1]*2 + [0]*400]
    type: raw
    value: '[1]*1 + [0]*750'
  states: {}
- name: Start_Stop
  id: variable_qtgui_chooser
  parameters:
    comment: GUI on/off switch for RF
    gui_hint: 0,2,1,2
    label: Pulse
    label0: Stop
    label1: Start
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: Gate to switch RF on/off
    enabled: Start_Stop
    showports: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      Added as suggested by 
      messages in warning
      window of GRC - not 
      really sure of its impact,
      but believe it protects
      CPU util - NB
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: DFS_Pattern
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: '20000000'
    comment: Sink for SDR (HackRF One)
    freq0: Channel_Center_Freq
    gain0: '10'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '20000000'
    comment: Visualization of the transmitted signal - NB
    fc: Channel_Center_Freq
    fftsize: '1024'
    plotconst: 'False'
    plotwaterfall: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_copy_0, '0', blocks_throttle_0, '0']
- [blocks_copy_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_copy_0, '0']

metadata:
  file_format: 1
